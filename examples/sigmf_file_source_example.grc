options:
  parameters:
    author: J. A. Gilbert
    copyright: J. A. Gilbert
    description: Example for using the SigMF File Source
    generate_options: qt_gui
    id: sigmf_file_source_example
    output_language: python
    title: SigMF File Source
  states: {}

blocks:
- name: sigmf_md
  id: variable
  parameters:
    value: '{''global'':{''core:sample_rate'':1234}, ''captures'':[], ''annotations'':[]}'
  states: {}
- name: throttle_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: pow(2,15)
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_sigmf_source_minimal_0
  id: blocks_sigmf_source_minimal
  parameters:
    file: sigmf_file.split('.')[0] + '.sigmf-data'
    repeat: 'True'
    type: complex short (sc16_le)
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: throttle_rate
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    note: ENABLE ONE SRC PATH
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,1,1,3
    size: '4096'
    srate: '1'
    tr_delay: '1500'
    tr_level: '0.15'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,4
    size: 4096*4
    srate: '1'
    tr_delay: '1500'
    tr_level: '0.15'
    type: complex
    update_time: '0.01'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '1'
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,1
    type: complex
  states: {}
- name: sigmf_file
  id: parameter
  parameters:
    label: sigmf_file
    short_id: f
    type: str
    value: /data/public/dect6.sigmf-meta
  states: {state: disabled}
- name: sigmf_file
  id: parameter
  parameters:
    label: sigmf_file
    short_id: f
    type: str
    value: /Users/jacob/dect6.sigmf-meta
  states: {}
- name: sigmf_utils_add_tags_from_sigmf_0
  id: sigmf_utils_add_tags_from_sigmf
  parameters:
    add_annotation_tags: 'True'
    metadata: sigmf_file
    start_tag_key: pmt.PMT_NIL
    type: complex
  states: {}
- name: sigmf_utils_sigmf_file_source_0
  id: sigmf_utils_sigmf_file_source
  parameters:
    add_begin_tag: pmt.PMT_NIL
    add_sigmf_tags: 'True'
    length: '0'
    output_type: complex
    repeat: 'True'
    sigmf_filename: sigmf_file
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_sigmf_source_minimal_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_throttle_0, '0', sigmf_utils_add_tags_from_sigmf_0, '0']
- [sigmf_utils_add_tags_from_sigmf_0, '0', qtgui_time_sink_x_0, '0']
- [sigmf_utils_add_tags_from_sigmf_0, '0', qtgui_time_sink_x_0_0, '0']
- [sigmf_utils_add_tags_from_sigmf_0, '0', qtgui_waterfall_sink_x_0, '0']
- [sigmf_utils_sigmf_file_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
