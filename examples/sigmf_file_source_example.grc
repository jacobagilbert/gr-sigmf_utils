options:
  parameters:
    author: J. A. Gilbert
    copyright: J. A. Gilbert
    description: Example for using the SigMF File Source
    generate_options: qt_gui
    id: sigmf_file_source_example
    output_language: python
    title: SigMF File Source
  states: {}

blocks:
- name: sigmf_md
  id: variable
  parameters:
    value: '{''global'':{''core:sample_rate'':1234}, ''captures'':[], ''annotations'':[]}'
  states: {}
- name: throttle_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    alias: throttle
    samples_per_second: throttle_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '102400'
    srate: '1'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '1'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: sigmf_file
  id: parameter
  parameters:
    label: sigmf_file
    short_id: f
    type: str
    value: /data/public/dect6.sigmf-meta
  states: {}
- name: sigmf_file_source
  id: sigmf_utils_sigmf_file_source
  parameters:
    alias: sigmf_file_source
    begin_tag: pmt.intern('asdf')
    length: '0'
    output_type: complex
    repeat: 'True'
    sigmf_filename: sigmf_file
  states: {}
- name: sigmf_utils_add_tags_from_sigmf_0
  id: sigmf_utils_add_tags_from_sigmf
  parameters:
    add_annotation_tags: 'True'
    metadata: sigmf_file
    type: complex
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle_0, '0', sigmf_utils_add_tags_from_sigmf_0, '0']
- [sigmf_file_source, '0', blocks_throttle_0, '0']
- [sigmf_utils_add_tags_from_sigmf_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
