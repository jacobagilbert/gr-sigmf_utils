options:
  parameters:
    author: J. A. Gilbert
    copyright: J. A. Gilbert
    description: Example for using the SigMF File Source
    generate_options: qt_gui
    id: sigmf_file_source_example
    output_language: python
    title: SigMF File Source Example
  states: {}

blocks:
- name: throttle_rate
  id: variable_qtgui_range
  parameters:
    label: Throttle
    outputmsgname: value
    showports: 'False'
    start: 10e3
    step: 1e3
    stop: 2000e3
    value: 50e3
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    alias: throttle
    samples_per_second: throttle_rate/5
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Example SigMF Recordings (including
      the DECT6 Recording used here) are
      available from this website:

      https://sigmf.azurewebsites.net/
    note: README
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '1'
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,1,1,1
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,2
    size: int(throttle_rate)
    srate: '1'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '1'
    fc: '0'
    fftsize: '256'
    gui_hint: 0,0,1,1
    type: complex
    update_time: '0.002'
  states: {}
- name: sigmf_file
  id: parameter
  parameters:
    label: sigmf_file
    short_id: f
    type: str
    value: /data/public/dect6.sigmf-data
  states: {}
- name: sigmf_file_source
  id: sigmf_utils_sigmf_file_source
  parameters:
    add_begin_tag: pmt.intern('asdf')
    add_sigmf_tags: 'True'
    alias: sigmf_file_source
    length: '0'
    output_type: complex
    repeat: 'True'
    sigmf_filename: sigmf_file
  states: {}

connections:
- [blocks_throttle_0, '0', blocks_tag_debug_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [sigmf_file_source, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
