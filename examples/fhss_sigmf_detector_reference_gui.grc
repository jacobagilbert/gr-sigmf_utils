options:
  parameters:
    author: J. Gilbert
    copyright: NTESS, LLC
    description: FHSS Utilities Reference Application
    generate_options: qt_gui
    id: fhss_detector_reference_gui
    output_language: python
    title: Burst Detector Reference
  states: {}

blocks:
- name: dec_att
  id: variable
  parameters:
    value: '40'
  states: {}
- name: dec_fc
  id: variable
  parameters:
    value: samp_rate / (decimation / 2.0)
  states: {}
- name: dec_fs
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: dec_twidth
  id: variable
  parameters:
    value: samp_rate / (decimation/2.0) * 0.1
  states: {}
- name: decim_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, dec_fs, dec_fc - dec_twidth / 2.0, dec_twidth, dec_att)
  states: {}
- name: fir_att
  id: variable
  parameters:
    value: '40'
  states: {}
- name: fir_fc
  id: variable
  parameters:
    value: '0.25'
  states: {}
- name: fir_fs
  id: variable
  parameters:
    comment: '|----------------------TAGGED BURST to PDU and PDU FIR FILTER CONFIG -----------------------|'
    value: samp_rate / (decimation/2.0)
  states: {}
- name: fir_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, 1, fir_fc - fir_twidth/2.0, fir_twidth, fir_att)
  states: {}
- name: fir_twidth
  id: variable
  parameters:
    value: '0.025'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: USRP Gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '76'
    value: '30'
  states: {state: disabled}
- name: len_dt
  id: variable
  parameters:
    value: len(decim_taps)
  states: {}
- name: len_ft
  id: variable
  parameters:
    value: len(fir_taps)
  states: {}
- name: raster_size
  id: variable
  parameters:
    value: '[64,256]'
  states: {}
- name: sample_limit
  id: variable
  parameters:
    value: '0'
  states: {}
- name: syncwords
  id: variable
  parameters:
    comment: |-
      UPDATE ME! Change the syncwords to match whatever
      unique word your target radio system uses. 

      Support multiple comma-separated values!
    value: '''101010101010101010101010100011, 101010101010101010101010100111'''
  states: {}
- name: tf
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Throttle Factor
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: add
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: add_noise_lvl
  id: parameter
  parameters:
    label: Noise
    type: eng_float
    value: '0'
  states: {}
- name: am_time_sink
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 4,1,3,1
    label1: ''
    name: '"AM Demodulation"'
    size: '102400'
    srate: samp_rate/decimation
    tr_delay: '.001'
    tr_level: '0.000001'
    type: msg_float
    update_time: '0.01'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: burst_tagger
  id: fhss_utils_fft_burst_tagger
  parameters:
    burst_post_len: int(round((float(samp_rate)/fft_size)*post_burst_time))
    burst_pre_len: int(round((float(samp_rate)/fft_size)*pre_burst_time))
    burst_width: burst_width
    center_frequency: center_freq
    debug: 'False'
    fft_size: fft_size
    history_size: int(round((float(samp_rate)/fft_size)*hist_time))
    lookahead: int(round((float(samp_rate)/fft_size)*lookahead_time))
    max_burst_len: '0'
    max_bursts: '0'
    minoutbuf: 1024*1000
    preload_nf: nf_preload
    preload_nf_bool: 'False'
    sample_rate: samp_rate
    threshold: threshold
  states: {}
- name: burst_tagger_time_sink
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,3
    label1: ' '
    label2: ' '
    name: '"Burst Tagger Threshold"'
    size: '102400'
    srate: '1'
    style2: '3'
    tr_delay: '.001'
    tr_level: '0.000001'
    type: msg_complex
    update_time: '0.001'
    ymax: '-30'
    ymin: '-100'
  states: {}
- name: burst_vsrc
  id: virtual_source
  parameters:
    stream_id: bursts
  states: {}
- name: burst_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '128'
    gui_hint: 1,3,1,1
    name: '"Burst Spectrogram"'
    showports: 'True'
    type: msg_complex
    update_time: '0.005'
  states: {}
- name: burst_width
  id: parameter
  parameters:
    hide: part
    label: Burst Width
    short_id: W
    type: intx
    value: int(1e6)
  states: {}
- name: bw_max
  id: parameter
  parameters:
    hide: part
    label: Max Valid Bandwidth
    short_id: B
    type: eng_float
    value: '0'
  states: {}
- name: bw_min
  id: parameter
  parameters:
    hide: part
    label: Min Valid Bandwidth
    short_id: b
    type: eng_float
    value: '0'
  states: {}
- name: center_freq
  id: parameter
  parameters:
    label: Frequency
    short_id: f
    type: eng_float
    value: 915e6
  states: {}
- name: cf_estimate
  id: fhss_utils_cf_estimate
  parameters:
    channel_freqs: '[]'
    method: fhss_utils.MIDDLE_OUT
    snr_min: cfe_snr
    thresh_min: '-25.0 - cfe_snr'
  states: {}
- name: cf_estimate_time_sink
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,3,1,1
    label1: ' '
    label2: ' '
    marker2: '0'
    name: '"Bandwidth Estimator"'
    size: '102400'
    srate: samp_rate/decimation*2
    style2: '0'
    tr_delay: '.001'
    tr_level: '0.000001'
    type: msg_complex
    update_time: '0.01'
    ymax: '-40'
    ymin: '-100'
  states: {}
- name: cfe_snr
  id: parameter
  parameters:
    label: Center Frequency Estimator SNR
    short_id: c
    type: eng_float
    value: '4'
  states: {}
- name: csv_writer
  id: sandia_utils_csv_writer
  parameters:
    add_metadata: 'False'
    data_type: '''uint8'''
    file: /tmp/burst_bits.csv
    metadata_format: '''start_offset(uint64), center_frequency(double), symbol_rate(uint64)'''
    precision: '0'
  states: {state: disabled}
- name: decimation
  id: parameter
  parameters:
    label: Decimation
    short_id: d
    type: intx
    value: '32'
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: FFT Size
    short_id: N
    type: intx
    value: '256'
  states: {}
- name: fm_time_sink
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,2,3,1
    label1: ''
    name: '"FM Demodulation"'
    size: '102400'
    srate: samp_rate/decimation
    tr_delay: '.001'
    tr_level: '0.000001'
    type: msg_float
    update_time: '0.01'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: freq_max
  id: parameter
  parameters:
    hide: part
    label: Maximum Frequency
    short_id: Q
    type: eng_float
    value: '0'
  states: {}
- name: freq_min
  id: parameter
  parameters:
    hide: part
    label: Minimum Frequency
    short_id: q
    type: eng_float
    value: '0'
  states: {}
- name: head_tail
  id: pdu_utils_pdu_head_tail
  parameters:
    histsize: raster_size[0]
    length: raster_size[1]
    pdu_type: pdu_utils.INPUTTYPE_UNPACKED_BYTE
  states: {}
- name: hist_time
  id: parameter
  parameters:
    hide: part
    label: Noise Estimate History (s)
    short_id: H
    type: eng_float
    value: '0.0005'
  states: {}
- name: in_vsink
  id: virtual_sink
  parameters:
    stream_id: input
  states: {}
- name: in_vsrc
  id: virtual_source
  parameters:
    stream_id: input
  states: {}
- name: in_vsrc2
  id: virtual_source
  parameters:
    stream_id: input
  states: {}
- name: infile
  id: parameter
  parameters:
    label: Input SigMF Data File Name
    short_id: i
    type: str
    value: /tmp/data.sigmf-data
  states: {}
- name: lookahead_time
  id: parameter
  parameters:
    hide: part
    label: Lookahead Time [s]
    short_id: L
    type: eng_float
    value: '0.0005'
  states: {}
- name: max_burst_time
  id: parameter
  parameters:
    hide: part
    label: Max Burst Time [s]
    short_id: M
    type: eng_float
    value: '0.5'
  states: {}
- name: min_burst_time
  id: parameter
  parameters:
    hide: part
    label: Min Burst Time [s]
    short_id: m
    type: eng_float
    value: '0.0002'
  states: {}
- name: msg_debug
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: msg_debug2
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: mult_const
  id: blocks_multiply_const_vxx
  parameters:
    const: '.1'
    type: complex
  states: {}
- name: nf_preload
  id: parameter
  parameters:
    comment: |-
      Advanced use only - if set to nonzero value it will initialize the
      noise floor to this number to enable sample-0 burst detection
    label: Noise Floor Preload
    type: eng_float
    value: '0'
  states: {}
- name: noise_src
  id: analog_fastnoise_source_x
  parameters:
    amp: add_noise_lvl
    comment: |-
      Optional noise impariment; useful
      to observe how changing the signal
      to noise ratio affects detection.
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: note0
  id: note
  parameters:
    comment: |-
      This is not the best way for general use,
      but allows users to specify the file
      format via command line parameters
    note: FILE INPUT
  states: {}
- name: note1
  id: note
  parameters:
    comment: |-
      The blocks here are also
      available  wrapped up in
      a python hier block
    note: README
  states: {}
- name: note3
  id: note
  parameters:
    comment: |-
      To open in URH, remove comma separations and change file extetnsion to *.txt:
              sed 's/,//g' burst_bits.csv > bits.txt
    note: <======
  states: {}
- name: note3_0
  id: note
  parameters:
    comment: |-
      To open in URH, remove comma separations and change file extetnsion to *.txt:
              sed 's/,//g' burst_bits.csv > bits.txt
    note: <======
  states: {}
- name: note4
  id: note
  parameters:
    note: ====> TO DEFRAMER
  states: {}
- name: outfile
  id: parameter
  parameters:
    label: Output SigMF Meta File Name
    short_id: o
    type: str
    value: /tmp/sigmf_output.sigmf-meta
  states: {}
- name: pack
  id: pdu_utils_pack_unpack
  parameters:
    bit_order: pdu_utils.BIT_ORDER_MSB_FIRST
    mode: pdu_utils.MODE_PACK_BYTE
  states: {}
- name: pdu_align
  id: pdu_utils_pdu_align
  parameters:
    match_mode: pdu_utils.ALIGN_FIRST_MATCH
    mode: pdu_utils.ALIGN_DROP
    offset: '-24'
    syncwords: syncwords
    threshold: '0'
  states: {}
- name: pdu_bw_filter
  id: pdu_utils_pdu_range_filter
  parameters:
    comment: |-
      Will filter signals saved to SigMF
      based on bandwidth (-b / -B)
    invert: 'False'
    key: pmt.intern("bandwidth")
    max: bw_max if bw_max else samp_rate
    min: bw_min
  states: {}
- name: pdu_cf_filter
  id: pdu_utils_pdu_range_filter
  parameters:
    comment: |-
      Will filter signals saved to SigMF
      based on frequency (-q / -Q)
    invert: 'False'
    key: pmt.intern("center_frequency")
    max: freq_max if freq_max else (center_freq + samp_rate/2.0)
    min: freq_min if freq_min else (center_freq - samp_rate/2.0)
  states: {}
- name: pdu_clock_recovery_hard
  id: pdu_utils_pdu_clock_recovery
  parameters:
    binary_slice: binary
    debug: 'False'
    win_type: pdu_utils.TUKEY_WIN
  states: {}
- name: pdu_clock_recovery_soft
  id: pdu_utils_pdu_clock_recovery
  parameters:
    binary_slice: none
    debug: 'False'
    win_type: pdu_utils.TUKEY_WIN
  states: {state: disabled}
- name: pdu_fir_filter
  id: pdu_utils_pdu_fir_filter
  parameters:
    decimation: '2'
    taps: fir_taps
  states: {}
- name: pdu_pdu_lambda_0
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda x: np.abs(x)'
    metadict: Uniform Vector
  states: {}
- name: pdu_quad_demod
  id: pdu_utils_pdu_quadrature_demod_cf
  parameters:
    sensitivity: '1.0'
  states: {}
- name: pdu_split
  id: pdu_utils_pdu_split
  parameters:
    comment: |-
      Enable the Message Debug ---->
      to see PDU Metadata printed
    pass_empty: 'False'
  states: {}
- name: pdu_time_measure
  id: pdu_utils_pdu_fine_time_measure
  parameters:
    average_width: '63'
    buffer_percent: '10'
    post_burst_time: '1e-5'
    pre_burst_time: '1e-5'
  states: {}
- name: pdu_utils_pdu_logger_0
  id: pdu_utils_pdu_logger
  parameters:
    logfile: '''/tmp/bursts/raw-'''
    pdus_per_file: '1'
  states: {}
- name: pdu_vs0
  id: virtual_sink
  parameters:
    stream_id: bursts
  states: {}
- name: post_burst_time
  id: parameter
  parameters:
    hide: part
    label: Post Burst Time [s]
    short_id: P
    type: eng_float
    value: '0.0002'
  states: {}
- name: pre_burst_time
  id: parameter
  parameters:
    hide: part
    label: Pre Burst Time [s]
    short_id: p
    type: eng_float
    value: '0.0002'
  states: {}
- name: probe_rate
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    comment: |-
      Enable the Message Debug ---->
      and disable the throttle block
      for benchmarking performance
    mintime: '500.0'
    type: complex
  states: {}
- name: raster
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '2'
    gui_hint: 3,0,1,2
    name: '"Bit Raster"'
    ncols: raster_size[1]
    nrows: raster_size[0]
    samp_rate: '1'
    type: msg_byte
    zmin: '0'
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: r
    type: intx
    value: int(40e6)
  states: {}
- name: section0
  id: note
  parameters:
    comment: |-
      .                                                                    |------------ INPUT/OUTPUT CONFIGURATION  -----------|                  |-------------------------- CORE DETECTOR CONFIGURATION -------------------------------|                      |------------- BURST BOUNDARY CONFIGURATION ----------------|

      --------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
      .                                                                                                                                                                                                                                  Input
    note: SECTION
  states: {}
- name: section1
  id: note
  parameters:
    comment: |-
      ---------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
      .                                                                                                                                                                                                                                  Burst Detection
    note: SECTION
  states: {}
- name: section2
  id: note
  parameters:
    comment: |-
      ---------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
      .                                                                                                                                                                                                                                  FM Demod and Symbol Recovery
    note: SECTION
  states: {}
- name: section3
  id: note
  parameters:
    comment: |-
      ---------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
      .                                                                                                                                                                                                                                  Align and Raster Select Bursts
    note: SECTION
  states: {}
- name: section4
  id: note
  parameters:
    comment: '---------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------'
    note: SECTION
  states: {}
- name: short_in
  id: parameter
  parameters:
    label: SC16 Input
    short_id: s
    type: intx
    value: '1'
  states: {}
- name: sigmf_label
  id: parameter
  parameters:
    hide: part
    label: SigMF Label
    short_id: l
    type: str
    value: '''radio1'''
  states: {}
- name: sigmf_meta_writer
  id: fhss_utils_sigmf_meta_writer
  parameters:
    comment: |-
      Optional: save SigMF
      annotations to view in
      a tool like inspectrum
    dtype: '''ci16_le'' if short_in else ''cf32_le'''
    filename: infile if outfile == '' else outfile
    freq: center_freq
    label: sigmf_label
    rate: int(samp_rate)
  states: {state: disabled}
- name: sigmf_utils_pdu_meta_writer_0
  id: sigmf_utils_pdu_meta_writer
  parameters:
    dtype: '''ci16_le'' if short_in else ''cf32_le'''
    filename: infile if outfile == '' else outfile
    freq: center_freq
    label: sigmf_label
    rate: int(samp_rate)
  states: {}
- name: sigmf_utils_sigmf_file_source_0
  id: sigmf_utils_sigmf_file_source
  parameters:
    add_begin_tag: pmt.PMT_NIL
    add_sigmf_tags: 'False'
    length: 0 if sample_limit == 0 else sample_limit
    output_type: complex
    repeat: True if sample_limit == 0 else False
    sigmf_filename: infile
  states: {}
- name: sigmf_utils_tag_meta_writer_0
  id: sigmf_utils_tag_meta_writer
  parameters:
    dtype: '''ci16_le'' if short_in else ''cf32_le'''
    filename: /tmp/x
    freq: center_freq
    label: sigmf_label
    rate: int(samp_rate)
  states: {}
- name: skiphead
  id: blocks_skiphead
  parameters:
    comment: For partial file processing
    num_items: '1024'
    type: complex
  states: {state: bypassed}
- name: snippet
  id: snippet
  parameters:
    code: |-
      # this needs to somehow be run before initialization to work properly
      # but the intention is to dynamically load key params from sigmf-meta
      # - frequency
      # - sample rate
      # - sigmf captures/global fields

      import json
      from os.path import splitext

      filename=self.infile
      if filename.endswith('.sigmf-data'):
          try:
              pre, ext = splitext(filename)
              self.meta_filename = pre + '.sigmf-meta'
              gr.log.notice("Looks like a sigmf-data file was specified, checking " + self.meta_filename)
              with open(self.meta_filename) as metafile:
                  sigmf_meta = json.load(metafile)
                  self.sigmf_captures = sigmf_meta['captures']
                  self.sigmf_global = sigmf_meta['global']
              if len(self.sigmf_captures) > 1:
                  print(len(self.sigmf_captures),"found, using capture [0]")
              self.sigmf_captures = self.sigmf_captures[0]
              freq = self.sigmf_captures['core:frequency']
              rate = int(round(self.sigmf_global['core:sample_rate'],0))
              print("got:\n\trate =",rate,"\n\tfreq =",freq,"\n")
          except Exception as e:
              print("attempt to load sigmf-meta file failed because ",e," - using preconfigured parameters")
    section: main_after_init
  states: {state: disabled}
- name: soft_syms
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 4,3,3,1
    label1: ''
    marker1: '0'
    name: '"Soft Symbols"'
    size: '102400'
    srate: '1'
    style1: '0'
    tr_delay: '.001'
    tr_level: '0.000001'
    type: msg_float
    update_time: '0.01'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: soft_syms_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 4,3,3,1
    label1: ''
    label2: ''
    name: '"Time Measure Debug"'
    size: '102400'
    srate: '1'
    tr_delay: '.001'
    tr_level: '0.000001'
    type: msg_complex
    update_time: '0.01'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: tagged_burst_to_pdu
  id: fhss_utils_tagged_burst_to_pdu
  parameters:
    decimation: int(decimation/2)
    max_burst_time: max_burst_time
    min_burst_time: min_burst_time
    relative_center_frequency: '0.0'
    relative_sample_rate: '1.0'
    relative_span: '1.0'
    sample_rate: samp_rate
    taps: decim_taps
    threads: '3'
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: Threshold (dB)
    short_id: t
    type: eng_float
    value: '20'
  states: {}
- name: throttle
  id: blocks_throttle
  parameters:
    comment: 'QT Widget: Throttle Factor'
    samples_per_second: samp_rate/10000 * pow(10,tf/10)
    type: complex
  states: {}
- name: uhd_source
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: gain
    minoutbuf: 2048*1000*0
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: vsink_syms
  id: virtual_sink
  parameters:
    stream_id: hard_syms
  states: {}
- name: vsrc_syms
  id: virtual_source
  parameters:
    stream_id: hard_syms
  states: {}
- name: waterfall_sink_in
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0,1,3
    int_max: '0'
    int_min: '-120'
    name: '"Input Spectrogram"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}

connections:
- [add, '0', mult_const, '0']
- [burst_tagger, '0', blocks_tag_debug_0, '0']
- [burst_tagger, '0', sigmf_utils_tag_meta_writer_0, '0']
- [burst_tagger, '0', tagged_burst_to_pdu, '0']
- [burst_tagger, debug, burst_tagger_time_sink, in]
- [burst_vsrc, '0', burst_waterfall, in]
- [burst_vsrc, '0', pdu_pdu_lambda_0, pdu]
- [burst_vsrc, '0', pdu_quad_demod, cpdus]
- [cf_estimate, debug, cf_estimate_time_sink, in]
- [cf_estimate, out, pdu_split, pdu_in]
- [cf_estimate, out, pdu_time_measure, pdu_in]
- [head_tail, head, raster, in]
- [in_vsrc, '0', probe_rate, '0']
- [in_vsrc, '0', waterfall_sink_in, '0']
- [in_vsrc2, '0', burst_tagger, '0']
- [mult_const, '0', in_vsink, '0']
- [noise_src, '0', add, '1']
- [pdu_align, pdu_out, csv_writer, in]
- [pdu_align, pdu_out, head_tail, pdu_in]
- [pdu_align, pdu_out, pack, pdu_in]
- [pdu_bw_filter, pdu_out, pdu_cf_filter, pdu_in]
- [pdu_cf_filter, pdu_out, sigmf_meta_writer, in]
- [pdu_cf_filter, pdu_out, sigmf_utils_pdu_meta_writer_0, in]
- [pdu_clock_recovery_hard, pdu_out, vsink_syms, '0']
- [pdu_clock_recovery_soft, pdu_out, soft_syms, in]
- [pdu_fir_filter, pdu_out, pdu_vs0, '0']
- [pdu_pdu_lambda_0, pdu, am_time_sink, in]
- [pdu_quad_demod, fpdus, fm_time_sink, in]
- [pdu_quad_demod, fpdus, pdu_clock_recovery_hard, pdu_in]
- [pdu_quad_demod, fpdus, pdu_clock_recovery_soft, pdu_in]
- [pdu_split, dict, msg_debug2, print]
- [pdu_time_measure, pdu_out, pdu_bw_filter, pdu_in]
- [pdu_time_measure, pdu_out, pdu_fir_filter, pdu_in]
- [pdu_time_measure, pdu_out, soft_syms_0, in]
- [probe_rate, rate, msg_debug, print]
- [sigmf_utils_sigmf_file_source_0, '0', skiphead, '0']
- [skiphead, '0', throttle, '0']
- [tagged_burst_to_pdu, cpdus, cf_estimate, in]
- [tagged_burst_to_pdu, cpdus, pdu_utils_pdu_logger_0, pdu_in]
- [throttle, '0', add, '0']
- [uhd_source, '0', in_vsink, '0']
- [vsrc_syms, '0', pdu_align, pdu_in]

metadata:
  file_format: 1
  grc_version: 3.10.4.0
